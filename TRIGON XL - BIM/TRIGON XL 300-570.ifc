Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2020-09-28T23:51:33
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20181011_1545(x64) - Exporter 17.0.511.0 - Альтернативный интерфейс 17.14.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Mon Sep 28 23:51:33 2020 * Host: 189-i7-2600k * Database: C:\Users\EAD1D~1.PID\AppData\Local\Temp\{E12EFAEC-6DC1-4DE0-9A22-13B2FEEF4927}\ifc * Database version: 5507 * Database creation date: Mon Sep 28 23:51:31 2020 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Mon Sep 28 23:51:31 2020 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Mon Sep 28 23:51:31 2020 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 55, 44, 59, 999999; RefLongitude: 37, 42, 0, 2746; RefElevation: 0 mm
Данные - ADSK_Титул Год выпуска: 2019
Идентификация - Вариант конструкции: Главная модель
Прочее - Категория: Сведения о проекте

# IfcBuilding
Данные - ADSK_Титул Год выпуска: 2019
Идентификация - Вариант конструкции: Главная модель
Прочее - Категория: Сведения о проекте

# IfcBuildingStorey, Этаж 01
LongName: Этаж 01; Elevation: 0 mm
Прочее - Категория: Уровни; Имя семейства: Уровень; Код типа: Уровень: Отметка уровня с именем; Семейство: Уровень: Отметка уровня с именем; Семейство и типоразмер: Уровень: Отметка уровня с именем; Тип: Уровень: Отметка уровня с именем
Идентификация - Имя типа: Отметка уровня с именем; Имя: Этаж 01; Несущие конструкции: no; Построение этажа: yes
Зависимости - Базовая отметка: Базовая точка проекта; Фасад: 0 mm
Графика - Вес линий: 1; Обозначение: ADSK_ОтметкаУровня_ГОСТ21-1101-2013: Уровень с именем; Образец линий: ADSK_Линия сетки; Стандартное обозначение второго конца: yes; Стандартное обозначение первого конца: yes; Цвет: 16711680
Размеры - Расчетная высота: 0 mm

# IfcEnergyConversionDevice: XL 300, BIMLIB_Котел_Конденсационный_Премиксный_ELCO_TrigonXL_150-570:XL 300:654972
In: Этаж 01
Type - Material: Color RGB 181-181-181, Color RGB 049-049-049, Color RGB 255-000-000, Color RGB 255-255-240
Type - Видимость - Фланец: yes
Type - Графика - Зона обслуживания_Глубина_Задняя часть: 450 mm; Зона обслуживания_Глубина_Лицевая часть: 800 mm; Кольцо отвода газов: 145 mm
Type - Данные - ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: ELCO; ADSK_Код изделия: 3581647; ADSK_Марка: TRIGON XL 300; ADSK_Наименование: Водотрубный премиксный конденсационный котел TRIGON XL, 285 кВт, максимальное давление 8 Бар; ELCO_Страна производства: Нидерланды
Type - Идентификация - ADSK_URL документации изделия: https://elco.net.ru/products/gas/trigonxl/; ADSK_URL страницы изделия: https://elco.net.ru/products/gas/trigonxl/; ADSK_Версия Revit: 2017; BL_BIM library: https://bimlib.pro/manufacturer/company/16987; BL_Email: support@ru.elco.net; BL_Разработано: support@bimlib.pro; URL: https://elco.net.ru/; Заголовок OmniClass: Hot Water Heat Generators; Изготовитель: ELCO Heating Solutions; Имя типа: XL 300; Номер OmniClass: 23.75.10.11.14; Описание: Высокоэффективные проточные водотрубные конденсационные котлы TRIGON XL разработаны для систем отопления и горячего водоснабжения жилых и административных зданий. В конструкции использованы проточные теплообменники. Первый теплообменник - из гладких труб (нержавеющая сталь). Второй и третий - из оребренных труб, нержавеющая сталь с лазерной сваркой основания ребра.Система водяного охлаждения камеры сгорания и теплообменных блоков выполнена гидроформингом.
Type - Механизмы - Гидравлическое сопротивление при номинальном расходе ΔT=20: 12000 Pa; Давление воды макс.: 800000 Pa; Давление воды мин.: 100000 Pa; Максимальная рабочая температура: 90 kg/K/s3; Максимальная разница температур между под и обр линией: 30 kg/K/s3; Номинальный расход при ΔT=20: 0.00338889 m3/s; Объем воды: 0.061 m3
Type - Механизмы - Нагрузки - Минимальная тепловая мощность при 50⁄30 ⁰С: 64000 W; Минимальная тепловая мощность при 80⁄60 ⁰С: 57000 W; Номинальная тепловая мощность при 50⁄30 ⁰С: 300000 W; Номинальная тепловая мощность при 80⁄60 ⁰С: 286000 W; Номинальная тепловая нагрузка макс: 291000 W; Номинальная тепловая нагрузка мин: 58000 W; Эффективность на макс при 50⁄30 ⁰С: 1.032; Эффективность на макс при 80⁄60 ⁰С: 0.982; Эффективность на мин при 50⁄30 ⁰С: 1.094; Эффективность на мин при 80⁄60 ⁰С: 0.971
Type - Механизмы - Расход - Максимальное давление газа: 5000 Pa; Максимальный расход газа: 0.00868807 m3/s; Минимальное давление природного газа G20: 1700 Pa; Минимальное давление природного газа G25: 2000 Pa; Минимальное давление СУГ G31: 3000 Pa; Минимальный расход газа: 0.00173164 m3/s; Номинальное давление природного газа G20: 2000 Pa; Номинальное давление природного газа G25: 2500 Pa; Номинальное давление СУГ G31: 3000 Pa; Фактическая калорийность газа: 8000
Type - Прочее - Категория: Оборудование; ADSK_Тепловая мощность: 286000 W; Имя семейства: BIMLIB_Котел_Конденсационный_Премиксный_ELCO_TrigonXL_150-570; Макс. температура дымовых газов при 80⁄60 ⁰С: 75 kg/K/s3; Максимальный объемный расход конденсата: 18,5 Л/ч; Максимальный остаточный напор дымовых газов после котла: 160 Pa; Максимальный уровень CO: 14 мг/кВт∙ч; Максимальный уровень NOx: 36 мг/кВт∙ч; Массовый расход дымовых газов макс: 388 кг/ч; Массовый расход дымовых газов мин: 83 кг/ч; Объемный расход дымовых газов макс: 377 кг/ч; Объемный расход дымовых газов мин: 77 кг/ч
Type - Размеры - ADSK_Размер_Высота: 1460 mm; ADSK_Размер_Глубина: 1348 mm; ADSK_Размер_Ширина: 748.5 mm; Внешний диаметр подключения воды: 76 mm; Внешний диаметр подключения газа: 48.3 mm; Высота воздухозабора: 1135 mm; Высота газового патрубка: 1156 mm; Высота отвода домовых газов: 490 mm; Высота подключения горячей воды: 968 mm; Высота подключения холодной воды: 602 mm; Высота слива: 178 mm; Глубина блока: 1152 mm; Кабельный ввод_Глубина: 91.2 mm; Кабельный ввод 1: 292.6 mm; Кабельный ввод 2: 362.6 mm; Максимальная высота: 1466 mm; Подключение воды: 65 mm; Подключение газа: 40 mm; Подключение дымохода: 200 mm; Подключение забора воздуха_для внешнего забора: 130 mm; Подключение слива конденсата: 32 mm; Привязка воздухозабора: 149 mm; Привязка колес: 42 mm; Привязка колеса: 60 mm; Привязка отвода домовых газов: 374.25 mm; Привязка подключений воды и газа: 129 mm; Смещение лицевой панели: 110 mm
Type - Силы - Уровень звуковой мощности: 70.3 дБ(А)
Type - Текст - ADSK_Масса: 434
Type - Электросети - Класс защиты от поражения электрическим током: IP20; Потребляемая котлом электрическая мощность макс: 230 W; Потребляемая котлом электрическая мощность мин: 50 W; Предохранитель: 16 A; Частота: 50 Hz
Видимость - Зона обслуживания: no
Графика - Зона обслуживания_Глубина_Левая сторона: 250 mm; Зона обслуживания_Глубина_Правая сторона: 450 mm
Зависимости - Блок электродов справа: yes; Основа: Уровень : Этаж 01; Смещение: 0 mm; Уровень: Уровень: Этаж 01
Идентификация - Марка: 34
Механизмы - ADSK_Расход воздуха приточный: 0 m3/s; ADSK_Расход жидкости: 0 m3/s; ELCO_Отвод дымовых газов: 0 m3/s; ELCO_Расход газа: 0 m3/s; ELCO_Слив: 0; Классификация систем: Приточная жидкость,Прочее,Обратная жидкость,Канализация,Приточный воздух,Мощность,Отработанный воздух
Прочее - Код типа: BIMLIB_Котел_Конденсационный_Премиксный_ELCO_TrigonXL_150-570: XL 300; Семейство: BIMLIB_Котел_Конденсационный_Премиксный_ELCO_TrigonXL_150-570: XL 300; Семейство и типоразмер: BIMLIB_Котел_Конденсационный_Премиксный_ELCO_TrigonXL_150-570: XL 300; Тип: BIMLIB_Котел_Конденсационный_Премиксный_ELCO_TrigonXL_150-570: XL 300
Размеры - Объем: 1.12807 m3
Стадии - Стадия возведения: Стадия 1
Электросети - Нагрузки - ADSK_Количество фаз: 1; ADSK_Напряжение: 230 V

# IfcEnergyConversionDevice: XL 400, BIMLIB_Котел_Конденсационный_Премиксный_ELCO_TrigonXL_150-570:XL 400:654980
In: Этаж 01
Type - Material: Color RGB 181-181-181, Color RGB 049-049-049, Color RGB 255-000-000, Color RGB 255-255-240
Type - Видимость - Фланец: yes
Type - Графика - Зона обслуживания_Глубина_Задняя часть: 450 mm; Зона обслуживания_Глубина_Лицевая часть: 800 mm; Кольцо отвода газов: 170 mm
Type - Данные - ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: ELCO; ADSK_Код изделия: 3581648; ADSK_Марка: TRIGON XL 400; ADSK_Наименование: Водотрубный премиксный конденсационный котел TRIGON XL, 381 кВт, максимальное давление 8 Бар; ELCO_Страна производства: Нидерланды
Type - Идентификация - ADSK_URL документации изделия: https://elco.net.ru/products/gas/trigonxl/; ADSK_URL страницы изделия: https://elco.net.ru/products/gas/trigonxl/; ADSK_Версия Revit: 2017; BL_BIM library: https://bimlib.pro/manufacturer/company/16987; BL_Email: support@ru.elco.net; BL_Разработано: support@bimlib.pro; URL: https://elco.net.ru/; Заголовок OmniClass: Hot Water Heat Generators; Изготовитель: ELCO Heating Solutions; Имя типа: XL 400; Номер OmniClass: 23.75.10.11.14; Описание: Высокоэффективные проточные водотрубные конденсационные котлы TRIGON XL разработаны для систем отопления и горячего водоснабжения жилых и административных зданий. В конструкции использованы проточные теплообменники. Первый теплообменник - из гладких труб (нержавеющая сталь). Второй и третий - из оребренных труб, нержавеющая сталь с лазерной сваркой основания ребра.Система водяного охлаждения камеры сгорания и теплообменных блоков выполнена гидроформингом.
Type - Механизмы - Гидравлическое сопротивление при номинальном расходе ΔT=20: 32000 Pa; Давление воды макс.: 800000 Pa; Давление воды мин.: 100000 Pa; Максимальная рабочая температура: 90 kg/K/s3; Максимальная разница температур между под и обр линией: 30 kg/K/s3; Номинальный расход при ΔT=20: 0.00452778 m3/s; Объем воды: 0.068 m3
Type - Механизмы - Нагрузки - Минимальная тепловая мощность при 50⁄30 ⁰С: 85000 W; Минимальная тепловая мощность при 80⁄60 ⁰С: 75000 W; Номинальная тепловая мощность при 50⁄30 ⁰С: 401000 W; Номинальная тепловая мощность при 80⁄60 ⁰С: 381000 W; Номинальная тепловая нагрузка макс: 388000 W; Номинальная тепловая нагрузка мин: 78000 W; Эффективность на макс при 50⁄30 ⁰С: 1.034; Эффективность на макс при 80⁄60 ⁰С: 0.983; Эффективность на мин при 50⁄30 ⁰С: 1.095; Эффективность на мин при 80⁄60 ⁰С: 0.969
Type - Механизмы - Расход - Максимальное давление газа: 5000 Pa; Максимальный расход газа: 0.0115841 m3/s; Минимальное давление природного газа G20: 1700 Pa; Минимальное давление природного газа G25: 2000 Pa; Минимальное давление СУГ G31: 3000 Pa; Минимальный расход газа: 0.00232876 m3/s; Номинальное давление природного газа G20: 2000 Pa; Номинальное давление природного газа G25: 2500 Pa; Номинальное давление СУГ G31: 3000 Pa; Фактическая калорийность газа: 8000
Type - Прочее - Категория: Оборудование; ADSK_Тепловая мощность: 381000 W; Имя семейства: BIMLIB_Котел_Конденсационный_Премиксный_ELCO_TrigonXL_150-570; Макс. температура дымовых газов при 80⁄60 ⁰С: 75 kg/K/s3; Максимальный объемный расход конденсата: 24,7 Л/ч; Максимальный остаточный напор дымовых газов после котла: 400 Pa; Максимальный уровень CO: 14 мг/кВт∙ч; Максимальный уровень NOx: 34 мг/кВт∙ч; Массовый расход дымовых газов макс: 517 кг/ч; Массовый расход дымовых газов мин: 111 кг/ч; Объемный расход дымовых газов макс: 502 кг/ч; Объемный расход дымовых газов мин: 102 кг/ч
Type - Размеры - ADSK_Размер_Высота: 1460 mm; ADSK_Размер_Глубина: 1496 mm; ADSK_Размер_Ширина: 748.5 mm; Внешний диаметр подключения воды: 76 mm; Внешний диаметр подключения газа: 48.3 mm; Высота воздухозабора: 1135 mm; Высота газового патрубка: 1156 mm; Высота отвода домовых газов: 490 mm; Высота подключения горячей воды: 968 mm; Высота подключения холодной воды: 602 mm; Высота слива: 178 mm; Глубина блока: 1302 mm; Кабельный ввод_Глубина: 91.2 mm; Кабельный ввод 1: 292.6 mm; Кабельный ввод 2: 362.6 mm; Максимальная высота: 1466 mm; Подключение воды: 65 mm; Подключение газа: 40 mm; Подключение дымохода: 250 mm; Подключение забора воздуха_для внешнего забора: 130 mm; Подключение слива конденсата: 32 mm; Привязка воздухозабора: 149 mm; Привязка колес: 42 mm; Привязка колеса: 60 mm; Привязка отвода домовых газов: 374.25 mm; Привязка подключений воды и газа: 129 mm; Смещение лицевой панели: 110 mm
Type - Силы - Уровень звуковой мощности: 77.3 дБ(А)
Type - Текст - ADSK_Масса: 496
Type - Электросети - Класс защиты от поражения электрическим током: IP20; Потребляемая котлом электрическая мощность макс: 504 W; Потребляемая котлом электрическая мощность мин: 54 W; Предохранитель: 16 A; Частота: 50 Hz
Видимость - Зона обслуживания: no
Графика - Зона обслуживания_Глубина_Левая сторона: 250 mm; Зона обслуживания_Глубина_Правая сторона: 450 mm
Зависимости - Блок электродов справа: yes; Смещение: 0 mm; Уровень: Уровень: Этаж 01; Основа: Уровень : Этаж 01
Идентификация - Марка: 35
Механизмы - ELCO_Слив: 0; ADSK_Расход воздуха приточный: 0 m3/s; ADSK_Расход жидкости: 0 m3/s; ELCO_Отвод дымовых газов: 0 m3/s; ELCO_Расход газа: 0 m3/s; Классификация систем: Приточная жидкость,Прочее,Обратная жидкость,Канализация,Приточный воздух,Мощность,Отработанный воздух
Прочее - Код типа: BIMLIB_Котел_Конденсационный_Премиксный_ELCO_TrigonXL_150-570: XL 400; Семейство: BIMLIB_Котел_Конденсационный_Премиксный_ELCO_TrigonXL_150-570: XL 400; Семейство и типоразмер: BIMLIB_Котел_Конденсационный_Премиксный_ELCO_TrigonXL_150-570: XL 400; Тип: BIMLIB_Котел_Конденсационный_Премиксный_ELCO_TrigonXL_150-570: XL 400
Размеры - Объем: 1.27733 m3
Стадии - Стадия возведения: Стадия 1
Электросети - Нагрузки - ADSK_Количество фаз: 1; ADSK_Напряжение: 230 V

# IfcEnergyConversionDevice: XL 500, BIMLIB_Котел_Конденсационный_Премиксный_ELCO_TrigonXL_150-570:XL 500:654988
In: Этаж 01
Type - Material: Color RGB 181-181-181, Color RGB 049-049-049, Color RGB 255-000-000, Color RGB 255-255-240
Type - Видимость - Фланец: yes
Type - Графика - Зона обслуживания_Глубина_Задняя часть: 450 mm; Зона обслуживания_Глубина_Лицевая часть: 800 mm; Кольцо отвода газов: 170 mm
Type - Данные - ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: ELCO; ADSK_Код изделия: 3581649; ADSK_Марка: TRIGON XL 500; ADSK_Наименование: Водотрубный премиксный конденсационный котел TRIGON XL, 477 кВт, максимальное давление 8 Бар; ELCO_Страна производства: Нидерланды
Type - Идентификация - ADSK_URL документации изделия: https://elco.net.ru/products/gas/trigonxl/; ADSK_URL страницы изделия: https://elco.net.ru/products/gas/trigonxl/; ADSK_Версия Revit: 2017; BL_BIM library: https://bimlib.pro/manufacturer/company/16987; BL_Email: support@ru.elco.net; BL_Разработано: support@bimlib.pro; URL: https://elco.net.ru/; Заголовок OmniClass: Hot Water Heat Generators; Изготовитель: ELCO Heating Solutions; Имя типа: XL 500; Номер OmniClass: 23.75.10.11.14; Описание: Высокоэффективные проточные водотрубные конденсационные котлы TRIGON XL разработаны для систем отопления и горячего водоснабжения жилых и административных зданий. В конструкции использованы проточные теплообменники. Первый теплообменник - из гладких труб (нержавеющая сталь). Второй и третий - из оребренных труб, нержавеющая сталь с лазерной сваркой основания ребра.Система водяного охлаждения камеры сгорания и теплообменных блоков выполнена гидроформингом.
Type - Механизмы - Гидравлическое сопротивление при номинальном расходе ΔT=20: 34000 Pa; Давление воды макс.: 800000 Pa; Давление воды мин.: 100000 Pa; Максимальная рабочая температура: 90 kg/K/s3; Максимальная разница температур между под и обр линией: 30 kg/K/s3; Номинальный расход при ΔT=20: 0.00563889 m3/s; Объем воды: 0.075 m3
Type - Механизмы - Нагрузки - Минимальная тепловая мощность при 50⁄30 ⁰С: 106000 W; Минимальная тепловая мощность при 80⁄60 ⁰С: 95000 W; Номинальная тепловая мощность при 50⁄30 ⁰С: 503000 W; Номинальная тепловая мощность при 80⁄60 ⁰С: 477000 W; Номинальная тепловая нагрузка макс: 485000 W; Номинальная тепловая нагрузка мин: 97000 W; Эффективность на макс при 50⁄30 ⁰С: 1.038; Эффективность на макс при 80⁄60 ⁰С: 0.983; Эффективность на мин при 50⁄30 ⁰С: 1.094; Эффективность на мин при 80⁄60 ⁰С: 0.975
Type - Механизмы - Расход - Максимальное давление газа: 5000 Pa; Максимальный расход газа: 0.0144801 m3/s; Минимальное давление природного газа G20: 1700 Pa; Минимальное давление природного газа G25: 2000 Pa; Минимальное давление СУГ G31: 3000 Pa; Минимальный расход газа: 0.00289602 m3/s; Номинальное давление природного газа G20: 2000 Pa; Номинальное давление природного газа G25: 2500 Pa; Номинальное давление СУГ G31: 3000 Pa; Фактическая калорийность газа: 8000
Type - Прочее - Категория: Оборудование; ADSK_Тепловая мощность: 477000 W; Имя семейства: BIMLIB_Котел_Конденсационный_Премиксный_ELCO_TrigonXL_150-570; Макс. температура дымовых газов при 80⁄60 ⁰С: 75 kg/K/s3; Максимальный объемный расход конденсата: 30,7 Л/ч; Максимальный остаточный напор дымовых газов после котла: 300 Pa; Максимальный уровень CO: 16 мг/кВт∙ч; Максимальный уровень NOx: 37 мг/кВт∙ч; Массовый расход дымовых газов макс: 647 кг/ч; Массовый расход дымовых газов мин: 138 кг/ч; Объемный расход дымовых газов макс: 628 кг/ч; Объемный расход дымовых газов мин: 128 кг/ч
Type - Размеры - ADSK_Размер_Высота: 1460 mm; ADSK_Размер_Глубина: 1646 mm; ADSK_Размер_Ширина: 748.5 mm; Внешний диаметр подключения воды: 76 mm; Внешний диаметр подключения газа: 60 mm; Высота воздухозабора: 1135 mm; Высота газового патрубка: 1156 mm; Высота отвода домовых газов: 490 mm; Высота подключения горячей воды: 968 mm; Высота подключения холодной воды: 602 mm; Высота слива: 178 mm; Глубина блока: 1452 mm; Кабельный ввод_Глубина: 91.2 mm; Кабельный ввод 1: 292.6 mm; Кабельный ввод 2: 362.6 mm; Максимальная высота: 1466 mm; Подключение воды: 65 mm; Подключение газа: 50 mm; Подключение дымохода: 250 mm; Подключение забора воздуха_для внешнего забора: 150 mm; Подключение слива конденсата: 32 mm; Привязка воздухозабора: 149 mm; Привязка колес: 42 mm; Привязка колеса: 60 mm; Привязка отвода домовых газов: 374.25 mm; Привязка подключений воды и газа: 129 mm; Смещение лицевой панели: 110 mm
Type - Силы - Уровень звуковой мощности: 77.3 дБ(А)
Type - Текст - ADSK_Масса: 540
Type - Электросети - Класс защиты от поражения электрическим током: IP20; Потребляемая котлом электрическая мощность макс: 620 W; Потребляемая котлом электрическая мощность мин: 64 W; Предохранитель: 16 A; Частота: 50 Hz
Видимость - Зона обслуживания: no
Графика - Зона обслуживания_Глубина_Левая сторона: 250 mm; Зона обслуживания_Глубина_Правая сторона: 450 mm
Зависимости - Блок электродов справа: yes; Смещение: 0 mm; Уровень: Уровень: Этаж 01; Основа: Уровень : Этаж 01
Идентификация - Вариант конструкции: Главная модель; Марка: 36
Механизмы - ELCO_Слив: 0; ADSK_Расход воздуха приточный: 0 m3/s; ADSK_Расход жидкости: 0 m3/s; ELCO_Отвод дымовых газов: 0 m3/s; ELCO_Расход газа: 0 m3/s; Классификация систем: Приточная жидкость,Прочее,Обратная жидкость,Канализация,Приточный воздух,Мощность,Отработанный воздух
Прочее - Код типа: BIMLIB_Котел_Конденсационный_Премиксный_ELCO_TrigonXL_150-570: XL 500; Семейство: BIMLIB_Котел_Конденсационный_Премиксный_ELCO_TrigonXL_150-570: XL 500; Семейство и типоразмер: BIMLIB_Котел_Конденсационный_Премиксный_ELCO_TrigonXL_150-570: XL 500; Тип: BIMLIB_Котел_Конденсационный_Премиксный_ELCO_TrigonXL_150-570: XL 500
Размеры - Объем: 1.4266 m3
Стадии - Стадия возведения: Стадия 1
Электросети - Нагрузки - ADSK_Количество фаз: 1; ADSK_Напряжение: 230 V

# IfcEnergyConversionDevice: XL 570, BIMLIB_Котел_Конденсационный_Премиксный_ELCO_TrigonXL_150-570:XL 570:655203
In: Этаж 01
Type - Material: Color RGB 181-181-181, Color RGB 049-049-049, Color RGB 255-000-000, Color RGB 255-255-240
Type - Видимость - Фланец: yes
Type - Графика - Зона обслуживания_Глубина_Задняя часть: 450 mm; Зона обслуживания_Глубина_Лицевая часть: 800 mm; Кольцо отвода газов: 170 mm
Type - Данные - ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: ELCO; ADSK_Код изделия: 3581650; ADSK_Марка: TRIGON XL 570; ADSK_Наименование: Водотрубный премиксный конденсационный котел TRIGON XL, 540 кВт, максимальное давление 8 Бар; ELCO_Страна производства: Нидерланды
Type - Идентификация - ADSK_URL документации изделия: https://elco.net.ru/products/gas/trigonxl/; ADSK_URL страницы изделия: https://elco.net.ru/products/gas/trigonxl/; ADSK_Версия Revit: 2017; BL_BIM library: https://bimlib.pro/manufacturer/company/16987; BL_Email: support@ru.elco.net; BL_Разработано: support@bimlib.pro; URL: https://elco.net.ru/; Заголовок OmniClass: Hot Water Heat Generators; Изготовитель: ELCO Heating Solutions; Имя типа: XL 570; Номер OmniClass: 23.75.10.11.14; Описание: Высокоэффективные проточные водотрубные конденсационные котлы TRIGON XL разработаны для систем отопления и горячего водоснабжения жилых и административных зданий. В конструкции использованы проточные теплообменники. Первый теплообменник - из гладких труб (нержавеющая сталь). Второй и третий - из оребренных труб, нержавеющая сталь с лазерной сваркой основания ребра.Система водяного охлаждения камеры сгорания и теплообменных блоков выполнена гидроформингом.
Type - Механизмы - Гидравлическое сопротивление при номинальном расходе ΔT=20: 57000 Pa; Давление воды макс.: 800000 Pa; Давление воды мин.: 100000 Pa; Максимальная рабочая температура: 90 kg/K/s3; Максимальная разница температур между под и обр линией: 30 kg/K/s3; Номинальный расход при ΔT=20: 0.00641667 m3/s; Объем воды: 0.082 m3
Type - Механизмы - Нагрузки - Минимальная тепловая мощность при 50⁄30 ⁰С: 133000 W; Минимальная тепловая мощность при 80⁄60 ⁰С: 120000 W; Номинальная тепловая мощность при 50⁄30 ⁰С: 573000 W; Номинальная тепловая мощность при 80⁄60 ⁰С: 540000 W; Номинальная тепловая нагрузка макс: 550000 W; Номинальная тепловая нагрузка мин: 122000 W; Эффективность на макс при 50⁄30 ⁰С: 1.042; Эффективность на макс при 80⁄60 ⁰С: 0.982; Эффективность на мин при 50⁄30 ⁰С: 1.092; Эффективность на мин при 80⁄60 ⁰С: 0.982
Type - Механизмы - Расход - Максимальное давление газа: 5000 Pa; Максимальный расход газа: 0.0164207 m3/s; Минимальное давление природного газа G20: 1700 Pa; Минимальное давление природного газа G25: 2000 Pa; Минимальное давление СУГ G31: 3000 Pa; Минимальный расход газа: 0.00364242 m3/s; Номинальное давление природного газа G20: 2000 Pa; Номинальное давление природного газа G25: 2500 Pa; Номинальное давление СУГ G31: 3000 Pa; Фактическая калорийность газа: 8000
Type - Прочее - Категория: Оборудование; ADSK_Тепловая мощность: 540000 W; Имя семейства: BIMLIB_Котел_Конденсационный_Премиксный_ELCO_TrigonXL_150-570; Макс. температура дымовых газов при 80⁄60 ⁰С: 76 kg/K/s3; Максимальный объемный расход конденсата: 34,8 Л/ч; Максимальный остаточный напор дымовых газов после котла: 400 Pa; Максимальный уровень CO: 18 мг/кВт∙ч; Максимальный уровень NOx: 40 мг/кВт∙ч; Массовый расход дымовых газов макс: 733 кг/ч; Массовый расход дымовых газов мин: 174 кг/ч; Объемный расход дымовых газов макс: 712 кг/ч; Объемный расход дымовых газов мин: 161 кг/ч
Type - Размеры - ADSK_Размер_Высота: 1460 mm; ADSK_Размер_Глубина: 1769 mm; ADSK_Размер_Ширина: 748.5 mm; Внешний диаметр подключения воды: 76 mm; Внешний диаметр подключения газа: 60 mm; Высота воздухозабора: 1135 mm; Высота газового патрубка: 1156 mm; Высота отвода домовых газов: 490 mm; Высота подключения горячей воды: 968 mm; Высота подключения холодной воды: 602 mm; Высота слива: 178 mm; Глубина блока: 1602 mm; Кабельный ввод_Глубина: 91.2 mm; Кабельный ввод 1: 292.6 mm; Кабельный ввод 2: 362.6 mm; Максимальная высота: 1466 mm; Подключение воды: 65 mm; Подключение газа: 50 mm; Подключение дымохода: 250 mm; Подключение забора воздуха_для внешнего забора: 150 mm; Подключение слива конденсата: 32 mm; Привязка воздухозабора: 149 mm; Привязка колес: 42 mm; Привязка колеса: 60 mm; Привязка отвода домовых газов: 374.25 mm; Привязка подключений воды и газа: 129 mm; Смещение лицевой панели: 110 mm
Type - Силы - Уровень звуковой мощности: 77.3 дБ(А)
Type - Текст - ADSK_Масса: 595
Type - Электросети - Класс защиты от поражения электрическим током: IP20; Потребляемая котлом электрическая мощность макс: 676 W; Потребляемая котлом электрическая мощность мин: 61 W; Предохранитель: 16 A; Частота: 50 Hz
Видимость - Зона обслуживания: no
Графика - Зона обслуживания_Глубина_Левая сторона: 250 mm; Зона обслуживания_Глубина_Правая сторона: 450 mm
Зависимости - Блок электродов справа: yes; Смещение: 0 mm; Основа: Уровень : Этаж 01; Уровень: Уровень: Этаж 01
Идентификация - Вариант конструкции: Главная модель; Марка: 37
Механизмы - ELCO_Слив: 0; ADSK_Расход воздуха приточный: 0 m3/s; ADSK_Расход жидкости: 0 m3/s; ELCO_Отвод дымовых газов: 0 m3/s; ELCO_Расход газа: 0 m3/s; Классификация систем: Приточная жидкость,Прочее,Обратная жидкость,Канализация,Приточный воздух,Мощность,Отработанный воздух
Прочее - Код типа: BIMLIB_Котел_Конденсационный_Премиксный_ELCO_TrigonXL_150-570: XL 570; Семейство: BIMLIB_Котел_Конденсационный_Премиксный_ELCO_TrigonXL_150-570: XL 570; Семейство и типоразмер: BIMLIB_Котел_Конденсационный_Премиксный_ELCO_TrigonXL_150-570: XL 570; Тип: BIMLIB_Котел_Конденсационный_Премиксный_ELCO_TrigonXL_150-570: XL 570
Размеры - Объем: 1.57552 m3
Стадии - Стадия возведения: Стадия 1
Электросети - Нагрузки - ADSK_Количество фаз: 1; ADSK_Напряжение: 230 V

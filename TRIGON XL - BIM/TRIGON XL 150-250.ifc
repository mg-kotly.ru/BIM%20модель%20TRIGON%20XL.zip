Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2020-09-28T23:53:52
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20181011_1545(x64) - Exporter 17.0.511.0 - Альтернативный интерфейс 17.14.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Mon Sep 28 23:53:52 2020 * Host: 189-i7-2600k * Database: C:\Users\EAD1D~1.PID\AppData\Local\Temp\{5D5A75EC-DD1A-495A-8FFF-E3690CCE1AED}\ifc * Database version: 5507 * Database creation date: Mon Sep 28 23:53:51 2020 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Mon Sep 28 23:53:51 2020 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Mon Sep 28 23:53:51 2020 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 55, 44, 59, 999999; RefLongitude: 37, 42, 0, 2746; RefElevation: 0 mm
Данные - ADSK_Титул Год выпуска: 2019
Идентификация - Вариант конструкции: Главная модель
Прочее - Категория: Сведения о проекте

# IfcBuilding
Данные - ADSK_Титул Год выпуска: 2019
Идентификация - Вариант конструкции: Главная модель
Прочее - Категория: Сведения о проекте

# IfcBuildingStorey, Этаж 01
LongName: Этаж 01; Elevation: 0 mm
Прочее - Категория: Уровни; Имя семейства: Уровень; Код типа: Уровень: Отметка уровня с именем; Семейство: Уровень: Отметка уровня с именем; Семейство и типоразмер: Уровень: Отметка уровня с именем; Тип: Уровень: Отметка уровня с именем
Идентификация - Имя типа: Отметка уровня с именем; Вариант конструкции: Главная модель; Имя: Этаж 01; Несущие конструкции: no; Построение этажа: yes
Зависимости - Базовая отметка: Базовая точка проекта; Фасад: 0 mm
Размеры - Расчетная высота: 0 mm
Графика - Вес линий: 1; Обозначение: ADSK_ОтметкаУровня_ГОСТ21-1101-2013: Уровень с именем; Образец линий: ADSK_Линия сетки; Стандартное обозначение второго конца: yes; Стандартное обозначение первого конца: yes; Цвет: 16711680

# IfcEnergyConversionDevice: XL 150, BIMLIB_Котел_Конденсационный_Премиксный_ELCO_TrigonXL_150-570:XL 150:654753
In: Этаж 01
Type - Material: Color RGB 181-181-181, Color RGB 049-049-049, Color RGB 255-000-000, Color RGB 255-255-240
Type - Видимость - Фланец: no
Type - Графика - Зона обслуживания_Глубина_Задняя часть: 450 mm; Зона обслуживания_Глубина_Лицевая часть: 800 mm; Кольцо отвода газов: 120 mm
Type - Данные - ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: ELCO; ADSK_Код изделия: 3581644; ADSK_Марка: TRIGON XL 150; ADSK_Наименование: Водотрубный премиксный конденсационный котел TRIGON XL, 142 кВт, максимальное давление 8 Бар; ELCO_Страна производства: Нидерланды
Type - Идентификация - ADSK_URL документации изделия: https://elco.net.ru/products/gas/trigonxl/; ADSK_URL страницы изделия: https://elco.net.ru/products/gas/trigonxl/; ADSK_Версия Revit: 2017; BL_BIM library: https://bimlib.pro/manufacturer/company/16987; BL_Email: support@ru.elco.net; BL_Разработано: support@bimlib.pro; URL: https://elco.net.ru/; Заголовок OmniClass: Hot Water Heat Generators; Изготовитель: ELCO Heating Solutions; Имя типа: XL 150; Номер OmniClass: 23.75.10.11.14; Описание: Высокоэффективные проточные водотрубные конденсационные котлы TRIGON XL разработаны для систем отопления и горячего водоснабжения жилых и административных зданий. В конструкции использованы проточные теплообменники. Первый теплообменник - из гладких труб (нержавеющая сталь). Второй и третий - из оребренных труб, нержавеющая сталь с лазерной сваркой основания ребра.Система водяного охлаждения камеры сгорания и теплообменных блоков выполнена гидроформингом.
Type - Механизмы - Гидравлическое сопротивление при номинальном расходе ΔT=20: 11000 Pa; Давление воды макс.: 800000 Pa; Давление воды мин.: 100000 Pa; Максимальная рабочая температура: 90 kg/K/s3; Максимальная разница температур между под и обр линией: 30 kg/K/s3; Номинальный расход при ΔT=20: 0.00169444 m3/s; Объем воды: 0.027 m3
Type - Механизмы - Нагрузки - Минимальная тепловая мощность при 50⁄30 ⁰С: 35000 W; Минимальная тепловая мощность при 80⁄60 ⁰С: 31000 W; Номинальная тепловая мощность при 50⁄30 ⁰С: 149000 W; Номинальная тепловая мощность при 80⁄60 ⁰С: 142000 W; Номинальная тепловая нагрузка макс: 145000 W; Номинальная тепловая нагрузка мин: 32000 W; Эффективность на макс при 50⁄30 ⁰С: 1.03; Эффективность на макс при 80⁄60 ⁰С: 0.982; Эффективность на мин при 50⁄30 ⁰С: 1.092; Эффективность на мин при 80⁄60 ⁰С: 0.974
Type - Механизмы - Расход - Максимальное давление газа: 5000 Pa; Максимальный расход газа: 0.00432911 m3/s; Минимальное давление природного газа G20: 1700 Pa; Минимальное давление природного газа G25: 2000 Pa; Минимальное давление СУГ G31: 3000 Pa; Минимальный расход газа: 0.000955389 m3/s; Номинальное давление природного газа G20: 2000 Pa; Номинальное давление природного газа G25: 2500 Pa; Номинальное давление СУГ G31: 3000 Pa; Фактическая калорийность газа: 8000
Type - Прочее - Категория: Оборудование; ADSK_Тепловая мощность: 142000 W; Имя семейства: BIMLIB_Котел_Конденсационный_Премиксный_ELCO_TrigonXL_150-570; Макс. температура дымовых газов при 80⁄60 ⁰С: 75 kg/K/s3; Максимальный объемный расход конденсата: 9,2 Л/ч; Максимальный остаточный напор дымовых газов после котла: 200 Pa; Максимальный уровень CO: 14 мг/кВт∙ч; Максимальный уровень NOx: 38 мг/кВт∙ч; Массовый расход дымовых газов макс: 193 кг/ч; Массовый расход дымовых газов мин: 46 кг/ч; Объемный расход дымовых газов макс: 188 кг/ч; Объемный расход дымовых газов мин: 43 кг/ч
Type - Размеры - ADSK_Размер_Высота: 1457 mm; ADSK_Размер_Глубина: 1349 mm; ADSK_Размер_Ширина: 468.5 mm; Внешний диаметр подключения воды: 60 mm; Внешний диаметр подключения газа: 48.3 mm; Высота воздухозабора: 1130 mm; Высота газового патрубка: 1128 mm; Высота отвода домовых газов: 482 mm; Высота подключения горячей воды: 968 mm; Высота подключения холодной воды: 602 mm; Высота слива: 178 mm; Глубина блока: 1165 mm; Кабельный ввод_Глубина: 92.8 mm; Кабельный ввод 1: 290.6 mm; Кабельный ввод 2: 360.6 mm; Максимальная высота: 1466 mm; Подключение воды: 50 mm; Подключение газа: 40 mm; Подключение дымохода: 150 mm; Подключение забора воздуха_для внешнего забора: 130 mm; Подключение слива конденсата: 32 mm; Привязка воздухозабора: 131 mm; Привязка колес: 42 mm; Привязка колеса: 60 mm; Привязка отвода домовых газов: 235.25 mm; Привязка подключений воды и газа: 104 mm; Смещение лицевой панели: 60 mm
Type - Силы - Уровень звуковой мощности: 70.3 дБ(А)
Type - Текст - ADSK_Масса: 290
Type - Электросети - Класс защиты от поражения электрическим током: IP20; Потребляемая котлом электрическая мощность макс: 176 W; Потребляемая котлом электрическая мощность мин: 48 W; Предохранитель: 16 A; Частота: 50 Hz
Видимость - Зона обслуживания: no
Графика - Зона обслуживания_Глубина_Левая сторона: 250 mm; Зона обслуживания_Глубина_Правая сторона: 450 mm
Зависимости - Блок электродов справа: yes; Основа: Уровень : Этаж 01; Смещение: 0 mm; Уровень: Уровень: Этаж 01
Идентификация - Марка: 31
Механизмы - ADSK_Расход воздуха приточный: 0 m3/s; ADSK_Расход жидкости: 0 m3/s; ELCO_Отвод дымовых газов: 0 m3/s; ELCO_Расход газа: 0 m3/s; ELCO_Слив: 0; Классификация систем: Приточная жидкость,Прочее,Обратная жидкость,Канализация,Приточный воздух,Мощность,Отработанный воздух
Прочее - Код типа: BIMLIB_Котел_Конденсационный_Премиксный_ELCO_TrigonXL_150-570: XL 150; Семейство: BIMLIB_Котел_Конденсационный_Премиксный_ELCO_TrigonXL_150-570: XL 150; Семейство и типоразмер: BIMLIB_Котел_Конденсационный_Премиксный_ELCO_TrigonXL_150-570: XL 150; Тип: BIMLIB_Котел_Конденсационный_Премиксный_ELCO_TrigonXL_150-570: XL 150
Размеры - Объем: 0.715243 m3
Стадии - Стадия возведения: Стадия 1
Электросети - Нагрузки - ADSK_Количество фаз: 1; ADSK_Напряжение: 230 V

# IfcEnergyConversionDevice: XL 200, BIMLIB_Котел_Конденсационный_Премиксный_ELCO_TrigonXL_150-570:XL 200:654890
In: Этаж 01
Type - Material: Color RGB 181-181-181, Color RGB 049-049-049, Color RGB 255-000-000, Color RGB 255-255-240
Type - Видимость - Фланец: no
Type - Графика - Зона обслуживания_Глубина_Задняя часть: 450 mm; Зона обслуживания_Глубина_Лицевая часть: 800 mm; Кольцо отвода газов: 120 mm
Type - Данные - ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: ELCO; ADSK_Код изделия: 3581645; ADSK_Марка: TRIGON XL 200; ADSK_Наименование: Водотрубный премиксный конденсационный котел TRIGON XL, 190 кВт, максимальное давление 8 Бар; ELCO_Страна производства: Нидерланды
Type - Идентификация - ADSK_URL документации изделия: https://elco.net.ru/products/gas/trigonxl/; ADSK_URL страницы изделия: https://elco.net.ru/products/gas/trigonxl/; ADSK_Версия Revit: 2017; BL_BIM library: https://bimlib.pro/manufacturer/company/16987; BL_Email: support@ru.elco.net; BL_Разработано: support@bimlib.pro; URL: https://elco.net.ru/; Заголовок OmniClass: Hot Water Heat Generators; Изготовитель: ELCO Heating Solutions; Имя типа: XL 200; Номер OmniClass: 23.75.10.11.14; Описание: Высокоэффективные проточные водотрубные конденсационные котлы TRIGON XL разработаны для систем отопления и горячего водоснабжения жилых и административных зданий. В конструкции использованы проточные теплообменники. Первый теплообменник - из гладких труб (нержавеющая сталь). Второй и третий - из оребренных труб, нержавеющая сталь с лазерной сваркой основания ребра.Система водяного охлаждения камеры сгорания и теплообменных блоков выполнена гидроформингом.
Type - Механизмы - Гидравлическое сопротивление при номинальном расходе ΔT=20: 27000 Pa; Давление воды макс.: 800000 Pa; Давление воды мин.: 100000 Pa; Максимальная рабочая температура: 90 kg/K/s3; Максимальная разница температур между под и обр линией: 30 kg/K/s3; Номинальный расход при ΔT=20: 0.00225 m3/s; Объем воды: 0.031 m3
Type - Механизмы - Нагрузки - Минимальная тепловая мощность при 50⁄30 ⁰С: 47000 W; Минимальная тепловая мощность при 80⁄60 ⁰С: 42000 W; Номинальная тепловая мощность при 50⁄30 ⁰С: 200000 W; Номинальная тепловая мощность при 80⁄60 ⁰С: 190000 W; Номинальная тепловая нагрузка макс: 194000 W; Номинальная тепловая нагрузка мин: 43000 W; Эффективность на макс при 50⁄30 ⁰С: 1.03; Эффективность на макс при 80⁄60 ⁰С: 0.982; Эффективность на мин при 50⁄30 ⁰С: 1.092; Эффективность на мин при 80⁄60 ⁰С: 0.974
Type - Механизмы - Расход - Максимальное давление газа: 5000 Pa; Максимальный расход газа: 0.00579205 m3/s; Минимальное давление природного газа G20: 1700 Pa; Минимальное давление природного газа G25: 2000 Pa; Минимальное давление СУГ G31: 3000 Pa; Минимальный расход газа: 0.0012838 m3/s; Номинальное давление природного газа G20: 2000 Pa; Номинальное давление природного газа G25: 2500 Pa; Номинальное давление СУГ G31: 3000 Pa; Фактическая калорийность газа: 8000
Type - Прочее - Категория: Оборудование; ADSK_Тепловая мощность: 190000 W; Имя семейства: BIMLIB_Котел_Конденсационный_Премиксный_ELCO_TrigonXL_150-570; Макс. температура дымовых газов при 80⁄60 ⁰С: 75 kg/K/s3; Максимальный объемный расход конденсата: 12,4 Л/ч; Максимальный остаточный напор дымовых газов после котла: 200 Pa; Максимальный уровень CO: 14 мг/кВт∙ч; Максимальный уровень NOx: 38 мг/кВт∙ч; Массовый расход дымовых газов макс: 259 кг/ч; Массовый расход дымовых газов мин: 61 кг/ч; Объемный расход дымовых газов макс: 251 кг/ч; Объемный расход дымовых газов мин: 57 кг/ч
Type - Размеры - ADSK_Размер_Высота: 1457 mm; ADSK_Размер_Глубина: 1499 mm; ADSK_Размер_Ширина: 468.5 mm; Внешний диаметр подключения воды: 60 mm; Внешний диаметр подключения газа: 48.3 mm; Высота воздухозабора: 1130 mm; Высота газового патрубка: 1128 mm; Высота отвода домовых газов: 482 mm; Высота подключения горячей воды: 968 mm; Высота подключения холодной воды: 602 mm; Высота слива: 178 mm; Глубина блока: 1315 mm; Кабельный ввод_Глубина: 92.8 mm; Кабельный ввод 1: 290.6 mm; Кабельный ввод 2: 360.6 mm; Максимальная высота: 1466 mm; Подключение воды: 50 mm; Подключение газа: 40 mm; Подключение дымохода: 150 mm; Подключение забора воздуха_для внешнего забора: 130 mm; Подключение слива конденсата: 32 mm; Привязка воздухозабора: 131 mm; Привязка колес: 42 mm; Привязка колеса: 60 mm; Привязка отвода домовых газов: 234.25 mm; Привязка подключений воды и газа: 104 mm; Смещение лицевой панели: 60 mm
Type - Силы - Уровень звуковой мощности: 70.3 дБ(А)
Type - Текст - ADSK_Масса: 332
Type - Электросети - Класс защиты от поражения электрическим током: IP20; Потребляемая котлом электрическая мощность макс: 267 W; Потребляемая котлом электрическая мощность мин: 48 W; Предохранитель: 16 A; Частота: 50 Hz
Видимость - Зона обслуживания: no
Графика - Зона обслуживания_Глубина_Левая сторона: 250 mm; Зона обслуживания_Глубина_Правая сторона: 450 mm
Зависимости - Блок электродов справа: yes; Смещение: 0 mm; Основа: Уровень : Этаж 01; Уровень: Уровень: Этаж 01
Идентификация - Вариант конструкции: Главная модель; Марка: 32
Механизмы - ELCO_Слив: 0; ADSK_Расход воздуха приточный: 0 m3/s; ADSK_Расход жидкости: 0 m3/s; ELCO_Отвод дымовых газов: 0 m3/s; ELCO_Расход газа: 0 m3/s; Классификация систем: Приточная жидкость,Прочее,Обратная жидкость,Канализация,Приточный воздух,Мощность,Отработанный воздух
Прочее - Код типа: BIMLIB_Котел_Конденсационный_Премиксный_ELCO_TrigonXL_150-570: XL 200; Семейство: BIMLIB_Котел_Конденсационный_Премиксный_ELCO_TrigonXL_150-570: XL 200; Семейство и типоразмер: BIMLIB_Котел_Конденсационный_Премиксный_ELCO_TrigonXL_150-570: XL 200; Тип: BIMLIB_Котел_Конденсационный_Премиксный_ELCO_TrigonXL_150-570: XL 200
Размеры - Объем: 0.808608 m3
Стадии - Стадия возведения: Стадия 1
Электросети - Нагрузки - ADSK_Количество фаз: 1; ADSK_Напряжение: 230 V

# IfcEnergyConversionDevice: XL 250, BIMLIB_Котел_Конденсационный_Премиксный_ELCO_TrigonXL_150-570:XL 250:654964
In: Этаж 01
Type - Material: Color RGB 181-181-181, Color RGB 049-049-049, Color RGB 255-000-000, Color RGB 255-255-240
Type - Видимость - Фланец: no
Type - Графика - Зона обслуживания_Глубина_Задняя часть: 450 mm; Зона обслуживания_Глубина_Лицевая часть: 800 mm; Кольцо отвода газов: 145 mm
Type - Данные - ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: ELCO; ADSK_Код изделия: 3581646; ADSK_Марка: TRIGON XL 250; ADSK_Наименование: Водотрубный премиксный конденсационный котел TRIGON XL, 237 кВт, максимальное давление 8 Бар; ELCO_Страна производства: Нидерланды
Type - Идентификация - ADSK_URL документации изделия: https://elco.net.ru/products/gas/trigonxl/; ADSK_URL страницы изделия: https://elco.net.ru/products/gas/trigonxl/; ADSK_Версия Revit: 2017; BL_BIM library: https://bimlib.pro/manufacturer/company/16987; BL_Email: support@ru.elco.net; BL_Разработано: support@bimlib.pro; URL: https://elco.net.ru/; Заголовок OmniClass: Hot Water Heat Generators; Изготовитель: ELCO Heating Solutions; Имя типа: XL 250; Номер OmniClass: 23.75.10.11.14; Описание: Высокоэффективные проточные водотрубные конденсационные котлы TRIGON XL разработаны для систем отопления и горячего водоснабжения жилых и административных зданий. В конструкции использованы проточные теплообменники. Первый теплообменник - из гладких труб (нержавеющая сталь). Второй и третий - из оребренных труб, нержавеющая сталь с лазерной сваркой основания ребра.Система водяного охлаждения камеры сгорания и теплообменных блоков выполнена гидроформингом.
Type - Механизмы - Гидравлическое сопротивление при номинальном расходе ΔT=20: 31000 Pa; Давление воды макс.: 800000 Pa; Давление воды мин.: 100000 Pa; Максимальная рабочая температура: 90 kg/K/s3; Максимальная разница температур между под и обр линией: 30 kg/K/s3; Номинальный расход при ΔT=20: 0.00280556 m3/s; Объем воды: 0.035 m3
Type - Механизмы - Нагрузки - Минимальная тепловая мощность при 50⁄30 ⁰С: 53000 W; Минимальная тепловая мощность при 80⁄60 ⁰С: 47000 W; Номинальная тепловая мощность при 50⁄30 ⁰С: 250000 W; Номинальная тепловая мощность при 80⁄60 ⁰С: 238000 W; Номинальная тепловая нагрузка макс: 242000 W; Номинальная тепловая нагрузка мин: 48000 W; Эффективность на макс при 50⁄30 ⁰С: 1.032; Эффективность на макс при 80⁄60 ⁰С: 0.982; Эффективность на мин при 50⁄30 ⁰С: 1.094; Эффективность на мин при 80⁄60 ⁰С: 0.971
Type - Механизмы - Расход - Максимальное давление газа: 5000 Pa; Максимальный расход газа: 0.00722513 m3/s; Минимальное давление природного газа G20: 1700 Pa; Минимальное давление природного газа G25: 2000 Pa; Минимальное давление СУГ G31: 3000 Pa; Минимальный расход газа: 0.00143308 m3/s; Номинальное давление природного газа G20: 2000 Pa; Номинальное давление природного газа G25: 2500 Pa; Номинальное давление СУГ G31: 3000 Pa; Фактическая калорийность газа: 8000
Type - Прочее - Категория: Оборудование; ADSK_Тепловая мощность: 238000 W; Имя семейства: BIMLIB_Котел_Конденсационный_Премиксный_ELCO_TrigonXL_150-570; Макс. температура дымовых газов при 80⁄60 ⁰С: 75 kg/K/s3; Максимальный объемный расход конденсата: 15,4 Л/ч; Максимальный остаточный напор дымовых газов после котла: 200 Pa; Максимальный уровень CO: 14 мг/кВт∙ч; Максимальный уровень NOx: 36 мг/кВт∙ч; Массовый расход дымовых газов макс: 323 кг/ч; Массовый расход дымовых газов мин: 69 кг/ч; Объемный расход дымовых газов макс: 313 кг/ч; Объемный расход дымовых газов мин: 64 кг/ч
Type - Размеры - ADSK_Размер_Высота: 1457 mm; ADSK_Размер_Глубина: 1649 mm; ADSK_Размер_Ширина: 468.5 mm; Внешний диаметр подключения воды: 60 mm; Внешний диаметр подключения газа: 48.3 mm; Высота воздухозабора: 1130 mm; Высота газового патрубка: 1128 mm; Высота отвода домовых газов: 482 mm; Высота подключения горячей воды: 968 mm; Высота подключения холодной воды: 602 mm; Высота слива: 178 mm; Глубина блока: 1465 mm; Кабельный ввод_Глубина: 92.8 mm; Кабельный ввод 1: 290.6 mm; Кабельный ввод 2: 360.6 mm; Максимальная высота: 1466 mm; Подключение воды: 50 mm; Подключение газа: 40 mm; Подключение дымохода: 200 mm; Подключение забора воздуха_для внешнего забора: 130 mm; Подключение слива конденсата: 32 mm; Привязка воздухозабора: 131 mm; Привязка колес: 42 mm; Привязка колеса: 60 mm; Привязка отвода домовых газов: 234.25 mm; Привязка подключений воды и газа: 104 mm; Смещение лицевой панели: 60 mm
Type - Силы - Уровень звуковой мощности: 70.3 дБ(А)
Type - Текст - ADSK_Масса: 336
Type - Электросети - Класс защиты от поражения электрическим током: IP20; Потребляемая котлом электрическая мощность макс: 286 W; Потребляемая котлом электрическая мощность мин: 53 W; Предохранитель: 16 A; Частота: 50 Hz
Видимость - Зона обслуживания: no
Графика - Зона обслуживания_Глубина_Левая сторона: 250 mm; Зона обслуживания_Глубина_Правая сторона: 450 mm
Зависимости - Блок электродов справа: yes; Смещение: 0 mm; Уровень: Уровень: Этаж 01; Основа: Уровень : Этаж 01
Идентификация - Марка: 33
Механизмы - ELCO_Слив: 0; ADSK_Расход воздуха приточный: 0 m3/s; ADSK_Расход жидкости: 0 m3/s; ELCO_Отвод дымовых газов: 0 m3/s; ELCO_Расход газа: 0 m3/s; Классификация систем: Приточная жидкость,Прочее,Обратная жидкость,Канализация,Приточный воздух,Мощность,Отработанный воздух
Прочее - Код типа: BIMLIB_Котел_Конденсационный_Премиксный_ELCO_TrigonXL_150-570: XL 250; Семейство: BIMLIB_Котел_Конденсационный_Премиксный_ELCO_TrigonXL_150-570: XL 250; Семейство и типоразмер: BIMLIB_Котел_Конденсационный_Премиксный_ELCO_TrigonXL_150-570: XL 250; Тип: BIMLIB_Котел_Конденсационный_Премиксный_ELCO_TrigonXL_150-570: XL 250
Размеры - Объем: 0.902062 m3
Стадии - Стадия возведения: Стадия 1
Электросети - Нагрузки - ADSK_Количество фаз: 1; ADSK_Напряжение: 230 V
